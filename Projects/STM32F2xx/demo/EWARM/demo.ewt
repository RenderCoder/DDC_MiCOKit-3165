<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MiCOKit-3162</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MiCOKit-F205</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>wifi_uart</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\LocalTcpServer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\MICOAppEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\MICOBonjour.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\RemoteTcpClient.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\SppProtocol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\UartRecv.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>MiCOKit-3162</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3162\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3162\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3162\platform_config.h</name>
      </file>
    </group>
    <group>
      <name>MiCOKit-F205</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MKF205\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MKF205\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MKF205\platform_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAES.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MiCOSRPServer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>libraries</name>
    <group>
      <name>daemons</name>
      <group>
        <name>http_server</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\http-strings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\http_parse.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_handle.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_ssi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_sys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_wsgi.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>Drivers</name>
      <group>
        <name>Button</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\keypad\gpio_button\button.c</name>
        </file>
      </group>
      <group>
        <name>MFiAuth</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCODriverMFiAuth\MiCODriverMFiAuth.a</name>
        </file>
      </group>
      <group>
        <name>SPI Flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\spi_flash\spi_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\spi_flash\spi_flash_platform.c</name>
        </file>
      </group>
      <group>
        <name>STM32_USB_Host_Library</name>
        <group>
          <name>Class</name>
          <group>
            <name>MSC</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc_bot.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc_scsi.c</name>
            </file>
          </group>
        </group>
        <group>
          <name>Core</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_core.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_ctlreq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_ioreq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_pipes.c</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>utilities</name>
      <group>
        <name>base64</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\base64\base64.c</name>
        </file>
      </group>
      <group>
        <name>jscon_c</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\arraylist.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\arraylist.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\bits.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_debug.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_inttypes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object_private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_tokener.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_tokener.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_util.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_util.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\linkhash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\linkhash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\printbuf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\printbuf.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\AESUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\CheckSumUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\HTTPUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\RingBufferUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SecurityUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SHAUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SocketUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\StringUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TimeUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TLVUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\URLUtils.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>mico</name>
    <group>
      <name>core</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\MiCO.1062.SDIO.Cortex-M3.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\MiCO.1062.SPI.Cortex-M3.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\mico_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\rf_driver\wlan_firmware.c</name>
      </file>
    </group>
    <group>
      <name>net</name>
      <group>
        <name>LwIP</name>
        <group>
          <name>mico</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\net\LwIP\mico\mico_socket.c</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>RTOS</name>
      <group>
        <name>FreeRTOS</name>
        <group>
          <name>mico</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\mico\mico_rtos.c</name>
          </file>
        </group>
        <group>
          <name>ver9.0.0</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\croutine.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\event_groups.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\MemMang\heap_3.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\list.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM3\port.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM3\portasm.s</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\queue.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\tasks.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\timers.c</name>
          </file>
        </group>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\mico_rtos_common.c</name>
      </file>
    </group>
    <group>
      <name>security</name>
      <group>
        <name>curve25519</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\Curve25519\curve25519-donna.c</name>
        </file>
      </group>
      <group>
        <name>SHA </name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\hkdf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\hmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\sha1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\sha224-256.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\sha384-512.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\usha.c</name>
        </file>
      </group>
      <group>
        <name>TLS</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\TLS\wolfSSL\Lib_wolfSSL.Cortex-M3.IAR.release.a</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\security\Sodium\Lib_Sodium.IAR.release.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SRP_6a\Lib_SRP6a.IAR.release.a</name>
      </file>
    </group>
    <group>
      <name>system</name>
      <group>
        <name>easylink</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\airkiss_discovery\airkiss_discovery.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\MFi_WAC\Lib_MFi_WAC.Cortex-M3.IAR.release.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\airkiss_discovery\lib_airkiss\libairkiss.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\system_easylink.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\system_easylink_delegate.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\system_easylink_wac.c</name>
        </file>
      </group>
      <group>
        <name>mdns</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mdns\mico_mdns.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mdns\mico_mdns.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mdns\system_discovery.c</name>
        </file>
      </group>
      <group>
        <name>qc_test</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\qc_test.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_cli.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_tcpip.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\config_server\config_server.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\config_server\config_server_menu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\command_console\mico_cli.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\command_console\mico_cli.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_monitor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_notification.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_para_storage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_power_daemon.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\system.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\system_misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftp_ota.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftp_ota.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftpc.o</name>
      </file>
    </group>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Cortex-M3</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\Cortex-M3\crt0_EWARM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\Cortex-M3\hardfault.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\Cortex-M3\platform_core.c</name>
      </file>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\EWARM\Retarget.c</name>
      </file>
    </group>
    <group>
      <name>MCU</name>
      <group>
        <name>STM32F2xx</name>
        <group>
          <name>EWARM</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\EWARM\startup_stm32f2xx_EWARM.s</name>
          </file>
        </group>
        <group>
          <name>Peripherals</name>
          <group>
            <name>Libraries</name>
            <group>
              <name>STM32F2xx_HAL_Driver</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_hcd.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_ll_usb.c</name>
              </file>
            </group>
            <group>
              <name>STM32F2xx_StdPeriph_Driver</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_aes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_des.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_tdes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_md5.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_sha1.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
              </file>
            </group>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_mcu_powersave.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_pwm.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_uart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_watchdog.c</name>
          </file>
        </group>
        <group>
          <name>wlan_bus_driver</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\wlan_bus_driver\wlan_bus_SDIO.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\wlan_bus_driver\wlan_bus_SPI.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\wlan_bus_driver\wlan_platform.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\platform_init.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\MCU\mico_platform_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\MCU\platform_nsclock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\MCU\wlan_platform_common.c</name>
      </file>
    </group>
  </group>
</project>


