<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MiCOKit-3162</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data/>
    </settings>
  </configuration>
  <configuration>
    <name>MICOKit-F205</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data/>
    </settings>
  </configuration>
  <group>
    <name>Board</name>
    <group>
      <name>MiCOKit-3162</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3162\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3162\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3162\platform_config.h</name>
      </file>
    </group>
    <group>
      <name>MICOKit-F205</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MKF205\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MKF205\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MKF205\platform_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>Bootloader</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\bootloader\BootloaderEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\bootloader\Getline.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\bootloader\menu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\bootloader\Update_for_OTA.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\bootloader\ymodem.c</name>
    </file>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAES.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MiCOSRPServer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>libraries</name>
    <group>
      <name>Drivers</name>
      <group>
        <name>Button</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\keypad\gpio_button\button.c</name>
        </file>
      </group>
      <group>
        <name>SPI Flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\spi_flash\spi_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\spi_flash\spi_flash_platform.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>utilities</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\CheckSumUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\RingBufferUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\StringUtils.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>mico</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\NoRTOS\rtos.c</name>
    </file>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Cortex-M3</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\Cortex-M3\crt0_EWARM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\Cortex-M3\hardfault.c</name>
      </file>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\EWARM\Retarget.c</name>
      </file>
    </group>
    <group>
      <name>MCU</name>
      <group>
        <name>STM32F2xx</name>
        <group>
          <name>EWARM</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\EWARM\startup_stm32f2xx_bootloader_EWARM.s</name>
          </file>
        </group>
        <group>
          <name>Peripherals</name>
          <group>
            <name>Libraries</name>
            <group>
              <name>STM32F2xx_HAL_Driver</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_hcd.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_ll_usb.c</name>
              </file>
            </group>
            <group>
              <name>STM32F2xx_StdPeriph_Driver</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_aes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_des.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_tdes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_md5.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_sha1.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\stm32f2xx_conf.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\libraries\system_stm32f2xx.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_mcu_powersave.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_pwm.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_uart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\peripherals\platform_watchdog.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F2xx\platform_init.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\MCU\mico_platform_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\MCU\platform_nsclock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\MCU\wlan_platform_common.c</name>
      </file>
    </group>
  </group>
</project>


