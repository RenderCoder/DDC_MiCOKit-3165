<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MiCOKit-G55</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\LocalTcpServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\MICOAppEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\MICOBonjour.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\RemoteTcpClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\SppProtocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\UartRecv.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>MiCOKit-G55</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MKG55\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MKG55\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MKG55\platform_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverNanoSecond.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\debug.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAES.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MiCOSRPServer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>libraries</name>
    <group>
      <name>daemon</name>
      <group>
        <name>homekit_server</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\homekit_server\Lib_HomeKit_Server.Cortex-M4F.IAR.release.a</name>
        </file>
      </group>
      <group>
        <name>http_server</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\http-strings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\http_parse.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_handle.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_ssi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_sys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_wsgi.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>Drivers</name>
      <group>
        <name>display</name>
        <group>
          <name>VGM128064</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\AsciiLib.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\AsciiLib.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\oled.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\oled.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\oledfont.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>keypad</name>
        <group>
          <name>gpio_button</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\keypad\gpio_button\button.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\keypad\gpio_button\button.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>led</name>
        <group>
          <name>P9813</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\rgb_led\P9813\hsb2rgb_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\rgb_led\P9813\hsb2rgb_led.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\rgb_led\P9813\rgb_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\rgb_led\P9813\rgb_led.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>MFiAuth</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCODriverMFiAuth\MiCODriverMFiAuth.a</name>
        </file>
      </group>
      <group>
        <name>MiCOKit-EXT</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext_def.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext_mfg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\motion_sensor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\motion_sensor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\temp_hum_sensor.c</name>
        </file>
      </group>
      <group>
        <name>MiCOKit-STmem</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_STmems\MiCOKit_STmems.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_STmems\MiCOKit_STmems.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_STmems\MiCOKit_STmems_def.h</name>
        </file>
      </group>
      <group>
        <name>motor</name>
        <group>
          <name>dc_motor</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\motor\dc_motor\dc_motor.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\motor\dc_motor\dc_motor.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>sensor</name>
        <group>
          <name>ADPS9930</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\APDS9930\APDS9930.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\APDS9930\APDS9930.h</name>
          </file>
        </group>
        <group>
          <name>BMA2x2</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMA2x2\bma2x2.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMA2x2\bma2x2.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMA2x2\bma2x2_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMA2x2\bma2x2_user.h</name>
          </file>
        </group>
        <group>
          <name>BME280</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BME280\bme280.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BME280\bme280.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BME280\bme280_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BME280\bme280_user.h</name>
          </file>
        </group>
        <group>
          <name>BMG160</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMG160\bmg160.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMG160\bmg160.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMG160\bmg160_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMG160\bmg160_user.h</name>
          </file>
        </group>
        <group>
          <name>BMM050</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMM050\bmm050.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMM050\bmm050.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMM050\bmm050_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMM050\bmm050_user.h</name>
          </file>
        </group>
        <group>
          <name>DHT11</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\DHT11\DHT11.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\DHT11\DHT11.h</name>
          </file>
        </group>
        <group>
          <name>HTS221</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\HTS221\hts221.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\HTS221\hts221.h</name>
          </file>
        </group>
        <group>
          <name>infrared_adc</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\infrared_adc\infrared_reflective.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\infrared_adc\infrared_reflective.h</name>
          </file>
        </group>
        <group>
          <name>light_adc</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\light_adc\light_sensor.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\light_adc\light_sensor.h</name>
          </file>
        </group>
        <group>
          <name>LPS25HB</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LPS25HB\lps25hb.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LPS25HB\lps25hb.h</name>
          </file>
        </group>
        <group>
          <name>LSM9DS1</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LSM9DS1\lsm9ds1.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LSM9DS1\lsm9ds1_acc_gyr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LSM9DS1\lsm9ds1_mag.c</name>
          </file>
        </group>
        <group>
          <name>UVIS25</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\UVIS25\uvis25.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\UVIS25\uvis25.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>SPI Flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\spi_flash\spi_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\spi_flash\spi_flash_platform.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>utilities</name>
      <group>
        <name>base64</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\base64\base64.c</name>
        </file>
      </group>
      <group>
        <name>json_c</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\arraylist.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_tokener.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_util.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\linkhash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\printbuf.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\AESUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\CheckSumUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\HTTPUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\RingBufferUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SecurityUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SHAUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SocketUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\StringUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TimeUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TLVUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\URLUtils.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>mico</name>
    <group>
      <name>core</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\MiCO.1062.SPI.Cortex-M4.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\mico_config.c</name>
      </file>
    </group>
    <group>
      <name>net</name>
      <group>
        <name>LwIP</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\net\LwIP\mico\mico_socket.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>RTOS</name>
      <group>
        <name>FreeRTOS</name>
        <group>
          <name>mico</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\mico\mico_rtos.c</name>
          </file>
        </group>
        <group>
          <name>ver9.0.0</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\croutine.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\event_groups.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\MemMang\heap_3.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\list.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F\port.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F\portasm.s</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\queue.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\tasks.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\timers.c</name>
          </file>
        </group>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\mico_rtos_common.c</name>
      </file>
    </group>
    <group>
      <name>security</name>
      <group>
        <name>curve25519</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\Curve25519\curve25519-donna.c</name>
        </file>
      </group>
      <group>
        <name>SHA</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\hkdf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\hmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\sha1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\sha224-256.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\sha384-512.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\usha.c</name>
        </file>
      </group>
      <group>
        <name>TLS</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\TLS\wolfSSL\Lib_wolfSSL.Cortex-M4F.IAR.release.a</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\security\Sodium\Lib_Sodium.IAR.release.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SRP_6a\Lib_SRP6a.IAR.release.a</name>
      </file>
    </group>
    <group>
      <name>system</name>
      <group>
        <name>easylink</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\airkiss_discovery\airkiss_discovery.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\MFi_WAC\Lib_MFi_WAC.Cortex-M4F.IAR.release.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\airkiss_discovery\lib_airkiss\libairkiss.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\system_easylink.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\system_easylink_delegate.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\system_easylink_wac.c</name>
        </file>
      </group>
      <group>
        <name>mdns</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mdns\mico_mdns.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mdns\mico_mdns.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mdns\system_discovery.c</name>
        </file>
      </group>
      <group>
        <name>qc_test</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\qc_test.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_cli.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_tcpip.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\config_server\config_server.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\config_server\config_server_menu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\command_console\mico_cli.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_monitor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_notification.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_para_storage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_power_daemon.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\system_misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftp_ota.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftpc.o</name>
      </file>
    </group>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Cortex-M4</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\Cortex-M4\crt0_EWARM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\Cortex-M4\hardfault.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\Cortex-M4\platform_core.c</name>
      </file>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\EWARM\close.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\EWARM\lseek.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\EWARM\remove.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\EWARM\Retarget.c</name>
      </file>
    </group>
    <group>
      <name>MCU</name>
      <group>
        <name>ATSAMG55</name>
        <group>
          <name>EWARM</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\EWARM\startup_ATSAMG55_EWARM.s</name>
          </file>
        </group>
        <group>
          <name>Peripherals</name>
          <group>
            <name>Libraries</name>
            <group>
              <name>asf-3.22.0</name>
              <group>
                <name>common</name>
                <group>
                  <name>services</name>
                  <group>
                    <name>clock</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\clock\samg\sysclk.c</name>
                    </file>
                  </group>
                  <group>
                    <name>sleepmgr</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\sleepmgr\sam\sleepmgr.c</name>
                    </file>
                  </group>
                </group>
                <group>
                  <name>utils</name>
                  <group>
                    <name>interrupt</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\utils\interrupt\interrupt_sam_nvic.c</name>
                    </file>
                  </group>
                </group>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\common\utils\interrupt\interrupt_sam_nvic.c</name>
                </file>
              </group>
              <group>
                <name>sam</name>
                <group>
                  <name>drivers</name>
                  <group>
                    <name>adc</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\adc\adc2.c</name>
                    </file>
                  </group>
                  <group>
                    <name>efc</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\efc\efc.c</name>
                    </file>
                  </group>
                  <group>
                    <name>flexcom</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\flexcom\flexcom.c</name>
                    </file>
                  </group>
                  <group>
                    <name>matrix</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\matrix\matrix.c</name>
                    </file>
                  </group>
                  <group>
                    <name>pdc</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pdc\pdc.c</name>
                    </file>
                  </group>
                  <group>
                    <name>pio</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pio\pio.c</name>
                    </file>
                  </group>
                  <group>
                    <name>pmc</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pmc\pmc.c</name>
                    </file>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pmc\sleep.c</name>
                    </file>
                  </group>
                  <group>
                    <name>rtt</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\rtt\rtt.c</name>
                    </file>
                  </group>
                  <group>
                    <name>spi</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\spi\spi.c</name>
                    </file>
                  </group>
                  <group>
                    <name>supc</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\supc\supc.c</name>
                    </file>
                  </group>
                  <group>
                    <name>twi</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\twi\twi.c</name>
                    </file>
                  </group>
                  <group>
                    <name>usart</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\usart\usart.c</name>
                    </file>
                  </group>
                  <group>
                    <name>wdt</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\wdt\wdt.c</name>
                    </file>
                  </group>
                </group>
                <group>
                  <name>services</name>
                  <group>
                    <name>flash_efc</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\services\flash_efc\flash_efc.c</name>
                    </file>
                  </group>
                </group>
                <group>
                  <name>utils</name>
                  <group>
                    <name>cmsis</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\source\templates\system_samg55.c</name>
                    </file>
                  </group>
                </group>
              </group>
            </group>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\platform_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\platform_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\platform_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\platform_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\platform_mcu_powersave.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\platform_nano_second.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\platform_pwm.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\platform_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\platform_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\platform_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\platform_uart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\peripherals\platform_watchdog.c</name>
          </file>
        </group>
        <group>
          <name>wlan_bus_driver</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\wlan_bus_driver\wlan_bus_SPI.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\wlan_bus_driver\wlan_platform.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\ATSAMG55\platform_init.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\MCU\mico_platform_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\MCU\wlan_platform_common.c</name>
      </file>
    </group>
  </group>
</project>


